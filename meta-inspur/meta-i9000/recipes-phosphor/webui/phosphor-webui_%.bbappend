FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI = "git://github.com/inspur-bmc/ocp-i9000-webui;protocol=https"
SRCREV = "43b2b9349af4f4f44a7e3fbde44e989c9e9f82a1"
